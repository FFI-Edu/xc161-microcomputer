# Keil uVision project MCPraktikum.uvproj, settings and files
target MCPraktikum_Simulation (166/167)
  device: XC161CJ-16F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xC000-0xCFFF) IROM(0xC00000-0xC1FFFF) CLOCK(20000000) MOD167 MODV2
  output: MCPraktikum +hex
  group Header
    ./: mcpr_xc161_timer.h mcpr_xc161_lcd.h Platform_Types.h
  group Source
    ./: mcpr_xc161_timer.c mcpr_xc161_ablauf.c mcpr_xc161_lcd.c
  group Misc
    ./: mcpr_xc_start_002.A66
target MCPraktikum_ULINKJTAG (166/167)
  device: XC161CJ-16F Infineon
  cpu: as above
  output: MCPraktikum +hex
