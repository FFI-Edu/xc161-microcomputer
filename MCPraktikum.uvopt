<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>MCPraktikum_Simulation</TargetName>
    <ToolsetNumber>0x2</ToolsetNumber>
    <ToolsetName>166/167</ToolsetName>
    <TargetOption>
      <MCS166>
        <Clock>16000000</Clock>
        <uocRom>0</uocRom>
        <uocXCAN>0</uocXCAN>
        <hadROM>1</hadROM>
        <hadXRAM>1</hadXRAM>
        <hadICAN>0</hadICAN>
        <uocIROM2>0</uocIROM2>
        <uocIROM3>0</uocIROM3>
        <uocXRAM3>0</uocXRAM3>
        <OnChipMemories>
          <Ocm1>
            <Type>1</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x100000</Size>
          </Ocm1>
          <Ocm2>
            <Type>0</Type>
            <StartAddress>0x180000</StartAddress>
            <Size>0x80000</Size>
          </Ocm2>
          <Ocm3>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </Ocm3>
          <Ocm4>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </Ocm4>
          <Ocm5>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </Ocm5>
          <Ocm6>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </Ocm6>
          <ICAN>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </ICAN>
          <IROM>
            <Type>1</Type>
            <StartAddress>0xc00000</StartAddress>
            <Size>0x20000</Size>
          </IROM>
          <XRAM>
            <Type>0</Type>
            <StartAddress>0xc000</StartAddress>
            <Size>0x1000</Size>
          </XRAM>
          <IRAM>
            <Type>0</Type>
            <StartAddress>0xf600</StartAddress>
            <Size>0x800</Size>
          </IRAM>
          <IROM2>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </IROM2>
          <IROM3>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </IROM3>
          <XRAM3>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </XRAM3>
        </OnChipMemories>
      </MCS166>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>120</PageWidth>
        <PageLength>65</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>0</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Data Sheet</Title>
          <Path>DATASHTS\INFINEON\XC161CJ_DS.PDF</Path>
        </Book>
        <Book>
          <Number>1</Number>
          <Title>Instruction Set Manual</Title>
          <Path>DATASHTS\INFINEON\c166sv2um.pdf</Path>
        </Book>
        <Book>
          <Number>2</Number>
          <Title>Peripheral Units User's Manual</Title>
          <Path>DATASHTS\INFINEON\XC161_PERIPH_UM.PDF</Path>
        </Book>
        <Book>
          <Number>3</Number>
          <Title>System Units User's Manual</Title>
          <Path>DATASHTS\INFINEON\XC161_SYS_UM.PDF</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>S166.DLL</SimDllName>
        <SimDllArguments>-cMODV2</SimDllArguments>
        <SimDlgDllName>D167.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pX161CJ</SimDlgDllArguments>
        <TargetDllName>S166.DLL</TargetDllName>
        <TargetDllArguments>-cMODV2</TargetDllArguments>
        <TargetDlgDllName>T167.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pX161CJ</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>1</uSim>
        <uTrg>0</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRunDeb>0</sRunDeb>
        <sLrtime>1</sLrtime>
        <nTsel>2</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile>.\mcpr_xc161_debug.ini</sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\UL2OCDS.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGD167</Key>
          <Name>(3052=-1,-1,-1,-1,0)(3051=-1,-1,-1,-1,0)(5017=-1,-1,-1,-1,0)(3053=-1,-1,-1,-1,0)(3055=-1,-1,-1,-1,0)(3054=-1,-1,-1,-1,0)(3061=-1,-1,-1,-1,0)(82=-1,-1,-1,-1,0)(3044=-1,-1,-1,-1,0)(3057=-1,-1,-1,-1,0)(3040=-1,-1,-1,-1,0)(3058=-1,-1,-1,-1,0)(3009=-1,-1,-1,-1,0)(3059=-1,-1,-1,-1,0)(3060=-1,-1,-1,-1,0)(3045=-1,-1,-1,-1,0)(3046=-1,-1,-1,-1,0)(3036=-1,-1,-1,-1,0)(3035=-1,-1,-1,-1,0)(3037=-1,-1,-1,-1,0)(3038=-1,-1,-1,-1,0)(3039=-1,-1,-1,-1,0)(91=-1,-1,-1,-1,0)(92=-1,-1,-1,-1,0)(3042=-1,-1,-1,-1,0)(98=-1,-1,-1,-1,0)(105=-1,-1,-1,-1,0)(3043=-1,-1,-1,-1,0)(3062=-1,-1,-1,-1,0)(68598=-1,-1,-1,-1,0)(3063=-1,-1,-1,-1,0)(68599=-1,-1,-1,-1,0)(5015=-1,-1,-1,-1,0)(3050=-1,-1,-1,-1,0)(3064=-1,-1,-1,-1,0)(3056=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGT167</Key>
          <Name>(3052=-1,-1,-1,-1,0)(3051=-1,-1,-1,-1,0)(5017=-1,-1,-1,-1,0)(3053=-1,-1,-1,-1,0)(3055=-1,-1,-1,-1,0)(3054=-1,-1,-1,-1,0)(3061=-1,-1,-1,-1,0)(82=-1,-1,-1,-1,0)(3044=-1,-1,-1,-1,0)(3057=-1,-1,-1,-1,0)(3040=-1,-1,-1,-1,0)(3058=-1,-1,-1,-1,0)(3009=-1,-1,-1,-1,0)(3059=-1,-1,-1,-1,0)(3060=-1,-1,-1,-1,0)(3045=-1,-1,-1,-1,0)(3046=-1,-1,-1,-1,0)(3036=-1,-1,-1,-1,0)(3035=-1,-1,-1,-1,0)(3037=-1,-1,-1,-1,0)(3038=-1,-1,-1,-1,0)(3039=-1,-1,-1,-1,0)(91=-1,-1,-1,-1,0)(92=-1,-1,-1,-1,0)(3042=-1,-1,-1,-1,0)(98=-1,-1,-1,-1,0)(105=-1,-1,-1,-1,0)(3043=-1,-1,-1,-1,0)(3062=-1,-1,-1,-1,0)(68598=-1,-1,-1,-1,0)(3063=-1,-1,-1,-1,0)(68599=-1,-1,-1,-1,0)(5015=-1,-1,-1,-1,0)(3050=-1,-1,-1,-1,0)(3064=-1,-1,-1,-1,0)(3056=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2OCDS</Key>
          <Name> -O4399 -F15 -S3 -U"U0862R8E" -C0 -B"" -G00("Infineon XC16x") -H00(20096083) -I00(8) -Q0"AM29x800BT" -J03 -L00 -N0100000 -M00</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>D167</Key>
          <Name>EA=0 ALE=0 RD=1 WR=1 RSTCFG=24511</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint>
        <Bp>
          <Number>0</Number>
          <Type>0</Type>
          <LineNumber>103</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <HtxType>0</HtxType>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MCPNeu\mcpr_xc161_timer.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
      </Breakpoint>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
    </TargetOption>
  </Target>

  <Target>
    <TargetName>MCPraktikum_ULINKJTAG</TargetName>
    <ToolsetNumber>0x2</ToolsetNumber>
    <ToolsetName>166/167</ToolsetName>
    <TargetOption>
      <MCS166>
        <Clock>16000000</Clock>
        <uocRom>0</uocRom>
        <uocXCAN>0</uocXCAN>
        <hadROM>1</hadROM>
        <hadXRAM>1</hadXRAM>
        <hadICAN>0</hadICAN>
        <uocIROM2>0</uocIROM2>
        <uocIROM3>0</uocIROM3>
        <uocXRAM3>0</uocXRAM3>
        <OnChipMemories>
          <Ocm1>
            <Type>1</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x100000</Size>
          </Ocm1>
          <Ocm2>
            <Type>0</Type>
            <StartAddress>0x180000</StartAddress>
            <Size>0x80000</Size>
          </Ocm2>
          <Ocm3>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </Ocm3>
          <Ocm4>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </Ocm4>
          <Ocm5>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </Ocm5>
          <Ocm6>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </Ocm6>
          <ICAN>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </ICAN>
          <IROM>
            <Type>1</Type>
            <StartAddress>0xc00000</StartAddress>
            <Size>0x20000</Size>
          </IROM>
          <XRAM>
            <Type>0</Type>
            <StartAddress>0xc000</StartAddress>
            <Size>0x1000</Size>
          </XRAM>
          <IRAM>
            <Type>0</Type>
            <StartAddress>0xf600</StartAddress>
            <Size>0x800</Size>
          </IRAM>
          <IROM2>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </IROM2>
          <IROM3>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </IROM3>
          <XRAM3>
            <Type>0</Type>
            <StartAddress>0x0</StartAddress>
            <Size>0x0</Size>
          </XRAM3>
        </OnChipMemories>
      </MCS166>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>120</PageWidth>
        <PageLength>65</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Data Sheet</Title>
          <Path>DATASHTS\INFINEON\XC161CJ_DS.PDF</Path>
        </Book>
        <Book>
          <Number>1</Number>
          <Title>Instruction Set Manual</Title>
          <Path>DATASHTS\INFINEON\c166sv2um.pdf</Path>
        </Book>
        <Book>
          <Number>2</Number>
          <Title>Peripheral Units User's Manual</Title>
          <Path>DATASHTS\INFINEON\XC161_PERIPH_UM.PDF</Path>
        </Book>
        <Book>
          <Number>3</Number>
          <Title>System Units User's Manual</Title>
          <Path>DATASHTS\INFINEON\XC161_SYS_UM.PDF</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>S166.DLL</SimDllName>
        <SimDllArguments>-cMODV2</SimDllArguments>
        <SimDlgDllName>D167.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pX161CJ</SimDlgDllArguments>
        <TargetDllName>S166.DLL</TargetDllName>
        <TargetDllArguments>-cMODV2</TargetDllArguments>
        <TargetDlgDllName>T167.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pX161CJ</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRunDeb>0</sRunDeb>
        <sLrtime>1</sLrtime>
        <nTsel>2</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\UL2OCDS.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGT167</Key>
          <Name>(3052=75,107,369,355,0)(3051=-1,-1,-1,-1,0)(5017=-1,-1,-1,-1,0)(3053=-1,-1,-1,-1,0)(3055=-1,-1,-1,-1,0)(3054=-1,-1,-1,-1,0)(3061=-1,-1,-1,-1,0)(82=-1,-1,-1,-1,0)(3044=-1,-1,-1,-1,0)(3057=-1,-1,-1,-1,0)(3040=-1,-1,-1,-1,0)(3058=-1,-1,-1,-1,0)(3009=-1,-1,-1,-1,0)(3059=-1,-1,-1,-1,0)(3060=-1,-1,-1,-1,0)(3045=-1,-1,-1,-1,0)(3046=-1,-1,-1,-1,0)(3036=150,107,372,428,0)(3035=150,107,372,519,0)(3037=150,107,372,428,0)(3038=-1,-1,-1,-1,0)(3039=-1,-1,-1,-1,0)(91=-1,-1,-1,-1,0)(92=-1,-1,-1,-1,0)(3042=-1,-1,-1,-1,0)(98=-1,-1,-1,-1,0)(105=-1,-1,-1,-1,0)(3043=-1,-1,-1,-1,0)(3062=-1,-1,-1,-1,0)(68598=-1,-1,-1,-1,0)(3063=-1,-1,-1,-1,0)(68599=-1,-1,-1,-1,0)(5015=-1,-1,-1,-1,0)(3050=-1,-1,-1,-1,0)(3064=-1,-1,-1,-1,0)(3056=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2OCDS</Key>
          <Name> -O4399 -F15 -S3 -U"U0862R8E" -C0 -B"" -G00("Infineon XC16x") -H00(20096083) -I00(8) -Q0"AM29x800BT" -J03 -L00 -N0100000 -M00</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>D167</Key>
          <Name>EA=0 ALE=0 RD=1 WR=1 RSTCFG=24511</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint>
        <Bp>
          <Number>0</Number>
          <Type>0</Type>
          <LineNumber>103</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <HtxType>0</HtxType>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>E:\MCPNeu\mcpr_xc161_timer.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
      </Breakpoint>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <SystemViewers>
        <Entry>
          <Name>System Viewer\GPT12E</Name>
          <WinId>35905</WinId>
        </Entry>
      </SystemViewers>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>Header</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>22</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\mcpr_xc161_timer.h</PathWithFileName>
      <FilenameWithoutPath>mcpr_xc161_timer.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>13</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>4</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\mcpr_xc161_lcd.h</PathWithFileName>
      <FilenameWithoutPath>mcpr_xc161_lcd.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\Platform_Types.h</PathWithFileName>
      <FilenameWithoutPath>Platform_Types.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Source</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>15</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>63</TopLine>
      <CurrentLine>91</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\mcpr_xc161_timer.c</PathWithFileName>
      <FilenameWithoutPath>mcpr_xc161_timer.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>29</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>24</TopLine>
      <CurrentLine>49</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\mcpr_xc161_ablauf.c</PathWithFileName>
      <FilenameWithoutPath>mcpr_xc161_ablauf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>22</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>117</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\mcpr_xc161_lcd.c</PathWithFileName>
      <FilenameWithoutPath>mcpr_xc161_lcd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Misc</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\mcpr_xc_start_002.A66</PathWithFileName>
      <FilenameWithoutPath>mcpr_xc_start_002.A66</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

</ProjectOpt>
