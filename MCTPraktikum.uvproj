# Keil uVision project MCTPraktikum.uvproj, settings and files
target MCPraktikum_Simulation (166/167)
  device: XC161CJ-16F Infineon
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xC000-0xCFFF) IROM(0xC00000-0xC1FFFF) CLOCK(20000000) MOD167 MODV2
  output: MCTPraktikum +hex
  group Headerdateien
    ./: mcpr_xc161_lcd.h
  group Quelldateien
    ./: mcpr_xc161_ablauf.c mcpr_xc_start_002.A66 mcpr_xc161_lcd.c
target MCPraktikum_ULINKJTAG (166/167)
  device: XC161CJ-16F Infineon
  cpu: as above
  output: MCTPraktikum
